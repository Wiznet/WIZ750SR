# Keil uVision project W7500x_S2E.uvproj, settings and files
target W7500x_S2E_Boot (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: W7500x_S2E_Boot +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: w7500_s2e_boot_gen_production_hex2bin.bat
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c misc: --feedback=unused.txt
  c include: ..\..\Libraries\CMSIS\Device\WIZnet\W7500\Include;..\..\Libraries\W7500x_stdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\WIZnet\W7500\Source\ARM;..\S2E_App\src;..\S2E_App\src\Configuration;.\src;..\..\ioLibrary\Ethernet;..\..\ioLibrary\Internet\DHCP;..\..\ioLibrary\Internet\DNS;..\..\ioLibrary\MDIO;..\..\ioLibrary\Application\loopback;.\src\Configuration;.\src\PlatformHandler;.\src\Serial_to_Ethernet;.\src\Callback
  memory RVCT4: ROM 0x0 size 0x7000
  memory RVCT5: ROM 0x7d00 size 0xff
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --feedback=unused.txt
--feedback_type=unused,iw
  group MDK-ARM
    ../../Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group CMSIS
    ../../Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group W7500_Periphs
    ../../Libraries/W7500x_stdPeriph_Driver/src/: W7500x_dualtimer.c W7500x_gpio.c W7500x_uart.c W7500x_wztoe.c W7500x_crg.c W7500x_wdt.c
  group ioLibrary
    ../../ioLibrary/Ethernet/: socket.c wizchip_conf.c
    ../../ioLibrary/MDIO/: W7500x_miim.c
    ../../ioLibrary/Internet/DHCP/: dhcp.c
  group Callback
    ./src/Callback/: dhcp_cb.c
  group Boot_Main
    ./src/: W7500x_it.c retarget.c main.c
  group Configuration
    ./src/Configuration/: segcp.c util.c
  group PlatformHandler
    ./src/PlatformHandler/: flashHandler.c storageHandler.c timerHandler.c uartHandler.c deviceHandler.c i2cHandler.c eepromHandler.c isr_vector.c
  group Shared_code_with_App
    ../S2E_App/src/: W7500x_board.c
    ../S2E_App/src/Configuration/: ConfigData.c
